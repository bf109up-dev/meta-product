require recipes-core/images/core-image-base.bb

SUMMARY = "Custom image for product-test0, based on core-image-base"

# Add product specific packages here
# IMAGE_INSTALL += "custom-package1 custom-package2"
